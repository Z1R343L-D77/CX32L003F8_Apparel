# Keil uVision project smg.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: CX32L003F8 XMC
  pack: XMC.CX32L003_DFP.1.0.7
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: smg
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --diag_suppress=550,177
  c include: ..\APP;..\BSP;..\DEVICE;..\FWLB\inc;..\SYSTEM;..\DRIVERS
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group DEVICE
    ../DEVICE/: system_cx32l003.c startup_cx32l003.s
  group FWLIB
    ../FWLB/src/: cx32l003_adc.c cx32l003_advtim.c cx32l003_awk.c cx32l003_beeper.c cx32l003_clktrim.c cx32l003_crc.c cx32l003_debug.c cx32l003_delay.c cx32l003_exti.c cx32l003_flash.c cx32l003_gpio.c cx32l003_i2c.c cx32l003_it.c cx32l003_iwdt.c cx32l003_lptimer.c cx32l003_lpuart.c cx32l003_lvd.c cx32l003_owire.c cx32l003_pca.c cx32l003_rcc.c cx32l003_rtc.c cx32l003_spi.c cx32l003_syscon.c cx32l003_timer.c cx32l003_uart.c cx32l003_vc.c cx32l003_wwdt.c misc.c
  group SYSTEM
    ../SYSTEM/: main.c system_gpio.c system_it.c
  group APP
    ../APP/: app_scheduler.c app_menu.c
  group BSP
    ../BSP/: bsp_led.c bsp_smg.c bsp_key.c bsp_flash.c
  group DRIVERS
    ../DRIVERS/: drv_key.c drv_fd612.C
software components: CMSIS:CORE 5.6.0
